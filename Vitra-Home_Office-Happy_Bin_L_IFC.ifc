Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-01-10T13:25:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 10 13:25:39 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{B3C9C7F8-33A5-4E63-AB51-4498FF0185F5}\ifc * Database version: 5507 * Database creation date: Mon Jan 10 13:25:38 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 10 13:25:38 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 10 13:25:38 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Happy Bin, Vitra-Home_Office-Happy_Bin_rfa:Happy Bin:423293
In: Level 1
Type - ElementType: Happy Bin; Material: Poppy Red
Type - Constraints - BinType: Happy_Bin
Type - Dimensions - NominalDepth: 300 mm; NominalHeight: 375 mm; NominalWidth: 300 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Home_Office-Happy_Bin_rfa; ManufacterURL: https://www.vitra.com/en; ManufacturerName: Vitra; NBSDescription: Waste bins; NBSReference: 45-35-72/380; ProductInformation: Office accessories designed by Michel Charlot introduce unusual organic-shaped designs to the usually austere office environment. Inspired by cartoons and sculptures, the different containers add a cheerful touch that will brighten up any setting.A sculpture by Hans Arp prompted Michel Charlot's design of the Happy Bin. While respecting industrial production methods and material properties, the slightly irregular shape of the waste paper bin was designed to appear almost to have grown naturally. The Happy Bin is made of durable plastic and comes in two sizes and a selection of colours.; Revision: n/a; Uniclass2: Pr_40_50_07_76; Uniclass2015Description: Waste bins; Uniclass2015Reference: Pr_40_50_07_96; Version: 1; VersionDate: 15/12/2021
Type - Identity Data - Cost: 0; Description: Office accessories designed by Michel Charlot introduce unusual organic-shaped designs to the usually austere office environment. Inspired by cartoons and sculptures, the different containers add a cheerful touch that will brighten up any setting.A sculpture by Hans Arp prompted Michel Charlot's design of the Happy Bin. While respecting industrial production methods and material properties, the slightly irregular shape of the waste paper bin was designed to appear almost to have grown naturally. The Happy Bin is made of durable plastic and comes in two sizes and a selection of colours.; Designer: Michel Charlot; Manufacturer: Vitra; Model: Happy Bin; OmniClass Number: 23.40.20.31; OmniClass Title: Refuse Disposal Furniture; Type Name: Happy Bin; URL: https://www.vitra.com/en-pl/product/happy-bin
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Recycling bins; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Home_Office-Happy_Bin_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Polypropylene; ModelNumber: 20315502; ModelReference: n/a; Name: Happy_Bin_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 300x300x375 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.315 m2; Volume: 0.03375 m3
Materials and Finishes - ColorMaterial: Poppy Red
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Vitra-Home_Office-Happy_Bin_rfa: Happy Bin; Family and Type: Vitra-Home_Office-Happy_Bin_rfa: Happy Bin; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Home_Office-Happy_Bin_rfa: Happy Bin; Type Id: Vitra-Home_Office-Happy_Bin_rfa: Happy Bin; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
